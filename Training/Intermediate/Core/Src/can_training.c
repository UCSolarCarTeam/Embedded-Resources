#include "peripheral_training.h"
#include <stdio.h>
#include <string.h>

/*
 * LESSON: CAN (Controller Area Network) is a two-wire BROADCAST bus built for noisy
 * places like cars. Many nodes share the same pair of wires (CAN_H and CAN_L). There are
 * no addresses and no chip selects: a node sends a MESSAGE with an IDENTIFIER, and every
 * node hears it. Each receiver uses FILTERS to decide which identifiers it cares about.
 *
 * A (classic) CAN data frame:
 *      | ID | control | 0 to 8 data bytes | CRC | ACK | ...
 *
 *   - ID:   says WHAT the message is ("battery voltage"), not WHO it is for.
 *   - DLC:  Data Length Code: how many data bytes (0 to 8 in classic CAN).
 *   - ACK:  any node that received the frame correctly pulls the ACK slot low. If NOBODY
 *           acknowledges, the sender sees an error and retries. So on a real bus you need
 *           at least two nodes.
 *
 * ARBITRATION: if two nodes start at once, the one with the LOWER identifier wins
 * without destroying the message. The other one waits and tries again. So the ID is
 * also the message's PRIORITY (0x001 beats 0x7FF).
 *
 * STANDARD vs EXTENDED IDENTIFIERS
 *      Standard (CAN 2.0A): 11-bit ID   0x000 to 0x7FF        = 2048 IDs
 *      Extended (CAN 2.0B): 29-bit ID   0x00000000 to 0x1FFFFFFF  = ~536 million IDs
 *   - Which one a frame uses is a single bit in the frame (IDE).
 *   - Extended = the 11-bit base ID plus an 18-bit extension, so frames are longer
 *     (more bits per message, slightly less bandwidth).
 *   - The big ID space lets protocols pack information INTO the ID (priority, message
 *     type, source node). That is why protocols like J1939 use 29-bit IDs.
 *   - Both kinds can share a bus. Filters are separate for standard and extended IDs.
 *   - Rule of thumb: standard IDs for a small closed network, extended when you want
 *     structured IDs or have many message types. In HAL you choose with
 *     FDCAN_STANDARD_ID or FDCAN_EXTENDED_ID.
 *
 * CLASSIC CAN vs CAN FD
 * The STM32H5 peripheral is called FDCAN: it can do classic CAN and CAN FD (up to 64
 * data bytes and a faster data phase). We use CLASSIC frames only (8 data bytes).
 *
 * REAL BUS vs LOOPBACK
 * A real bus needs a CAN transceiver chip between the MCU pins (TX/RX) and the bus, a
 * 120 ohm termination resistor at each end, and the same bit rate on every node.
 * In INTERNAL LOOPBACK mode the peripheral is disconnected from the pins and receives
 * its own frames. No second node, transceiver or wiring is needed, so it is the
 * perfect way to learn the software side.
 *
 * RECEIVING WITH A CALLBACK (INTERRUPT)
 * You do not know WHEN a message will arrive, so instead of waiting for it in a loop we
 * let the hardware tell us. When a message lands in RX FIFO 0:
 *
 *      FDCAN interrupt -> FDCAN1_IT0_IRQHandler   (generated by CubeMX, calls HAL)
 *                      -> HAL_FDCAN_RxFifo0Callback()   <- the function YOU write
 *
 * Rules for code that runs inside an interrupt / callback:
 *   - Keep it SHORT: take the message out of the FIFO, store it, set a flag. That is all.
 *   - NEVER wait or print in there (no HAL_Delay, no UART transmit). The main loop
 *     notices the flag and does the slow work. That is why printing happens in main.
 *   - Variables shared between a callback and main must be "volatile".
 *
 * HOW A MESSAGE FLOWS ON THE STM32 (FDCAN)
 *      TX:  you fill a TX HEADER (ID, type, length...) and the data bytes
 *           -> HAL_FDCAN_AddMessageToTxFifoQ -> it goes into the TX FIFO/queue
 *           -> the peripheral sends it when the bus is free
 *      RX:  a frame arrives -> passes the FILTERS -> goes into RX FIFO 0
 *           -> interrupt -> callback -> HAL_FDCAN_GetRxMessage gives you the
 *              RX HEADER and the data -> main prints it over the UART
 *
 * CubeMX already initialised the peripheral (FDCAN1, internal loopback, classic frame
 * format, one extended filter, FDCAN1 interrupt 0 enabled in the NVIC). It must still
 * be STARTED with HAL_FDCAN_Start(), and the receive notification switched on.
 *
 * HAL CAN functions return HAL_OK, HAL_ERROR, HAL_BUSY or HAL_TIMEOUT.
 * Do the UART training first: received messages are printed over the UART.
 */

/* Filled in by the callback (interrupt), read by main */
static volatile uint8_t can_rx_flag = 0;       /* 1 = a new message is waiting */
static volatile uint32_t can_rx_id  = 0;
static volatile uint8_t can_rx_ext  = 0;
static volatile uint8_t can_rx_data[8] = {0};

/* -------------------------------------------------------------------------- */
/*  Part 1: Filters, Start and Interrupts                                     */
/* -------------------------------------------------------------------------- */

HAL_StatusTypeDef CAN_Training_Start(void)
{
    FDCAN_FilterTypeDef filter = {0};
    HAL_StatusTypeDef status;

    /* PROVIDED: read this, it is how a receiver chooses what to accept.
       A MASK filter accepts a frame when (frame ID & mask) == (FilterID1 & mask).
       With ID = 0 and mask = 0, no bits are compared, so EVERY extended ID is accepted
       and stored in RX FIFO 0. */
    filter.IdType       = FDCAN_EXTENDED_ID;          /* this filter is for 29-bit IDs      */
    filter.FilterIndex  = 0;                          /* filter number 0                    */
    filter.FilterType   = FDCAN_FILTER_MASK;          /* ID + mask                          */
    filter.FilterConfig = FDCAN_FILTER_TO_RXFIFO0;    /* matching frames go to RX FIFO 0    */
    filter.FilterID1    = 0x00000000U;                /* the ID                             */
    filter.FilterID2    = 0x00000000U;                /* the mask (0 = accept everything)   */

    status = HAL_FDCAN_ConfigFilter(&TRAINING_CAN_HANDLE, &filter);
    if (status != HAL_OK) return status;

    /* PROVIDED: what to do with frames that match NO filter. We have no standard-ID
       filter, so with FDCAN_REJECT standard (11-bit) frames are thrown away.
       The last two arguments reject remote-request frames. */
    status = HAL_FDCAN_ConfigGlobalFilter(&TRAINING_CAN_HANDLE,
                                          FDCAN_REJECT,          /* non-matching standard IDs */
                                          FDCAN_REJECT,          /* non-matching extended IDs */
                                          FDCAN_REJECT_REMOTE,   /* standard remote frames    */
                                          FDCAN_REJECT_REMOTE);  /* extended remote frames    */
    if (status != HAL_OK) return status;

    /* TODO 1: Start the peripheral. Until you do, nothing is sent or received.
               Return the status if it is not HAL_OK.

    // status = HAL_FDCAN_Start(
    //     FDCAN_HandleTypeDef *hfdcan  // Pointer to the FDCAN handle (&TRAINING_CAN_HANDLE)
    // );
    */

    /* TODO 2: Ask for an interrupt (and so a callback) whenever a NEW MESSAGE arrives
               in RX FIFO 0.

    // status = HAL_FDCAN_ActivateNotification(
    //     FDCAN_HandleTypeDef *hfdcan, // Pointer to the FDCAN handle
    //     uint32_t ActiveITs,          // Which events to enable: FDCAN_IT_RX_FIFO0_NEW_MESSAGE
    //     uint32_t BufferIndexes       // Only used for TX buffers. Use 0 here
    // );
    */

    return HAL_ERROR;   /* TODO: return HAL_OK when both calls succeeded */
}

/* -------------------------------------------------------------------------- */
/*  Part 2: Transmitting                                                      */
/* -------------------------------------------------------------------------- */

HAL_StatusTypeDef CAN_Training_Transmit(uint32_t id, uint8_t is_extended, const uint8_t data[8])
{
    FDCAN_TxHeaderTypeDef header = {0};
    HAL_StatusTypeDef status = HAL_ERROR;

    if (data == NULL) return HAL_ERROR;

    /* TODO 1: Fill the TX header. One assignment per field:

        header.Identifier          = id;                       the ID (11-bit max 0x7FF, 29-bit max 0x1FFFFFFF)
        header.IdType              = ...;                      FDCAN_EXTENDED_ID if is_extended, otherwise FDCAN_STANDARD_ID
        header.TxFrameType         = FDCAN_DATA_FRAME;         a data frame (not a remote request)
        header.DataLength          = FDCAN_DLC_BYTES_8;        send 8 data bytes
        header.ErrorStateIndicator = FDCAN_ESI_ACTIVE;         normal (error-active) node
        header.BitRateSwitch       = FDCAN_BRS_OFF;            no faster data phase (that is CAN FD)
        header.FDFormat            = FDCAN_CLASSIC_CAN;        classic CAN frame, not CAN FD
        header.TxEventFifoControl  = FDCAN_NO_TX_EVENTS;       we do not need a log of sent frames
        header.MessageMarker       = 0;                        user tag, not used
    */

    /* TODO 2: Put the message in the TX queue.

    // status = HAL_FDCAN_AddMessageToTxFifoQ(
    //     FDCAN_HandleTypeDef *hfdcan,             // Pointer to the FDCAN handle (&TRAINING_CAN_HANDLE)
    //     const FDCAN_TxHeaderTypeDef *pTxHeader,  // The header you filled in (&header)
    //     const uint8_t *pTxData                   // The 8 data bytes (cast to (uint8_t *) if the compiler complains)
    // );
    */

    (void)id;
    (void)is_extended;

    return status;
}

/* -------------------------------------------------------------------------- */
/*  Part 3: Receiving with a Callback                                         */
/* -------------------------------------------------------------------------- */

void HAL_FDCAN_RxFifo0Callback(FDCAN_HandleTypeDef *hfdcan, uint32_t RxFifo0ITs)
{
    FDCAN_RxHeaderTypeDef header = {0};
    uint8_t data[8] = {0};

    if (hfdcan->Instance != TRAINING_CAN_HANDLE.Instance) return;

    /* TODO 1: Only continue if the interrupt really was a NEW MESSAGE:
            (RxFifo0ITs & FDCAN_IT_RX_FIFO0_NEW_MESSAGE) != 0U   */

    /* TODO 2: Take the message out of RX FIFO 0.

    // status = HAL_FDCAN_GetRxMessage(
    //     FDCAN_HandleTypeDef *hfdcan,         // The handle HAL gave to this callback (hfdcan)
    //     uint32_t RxLocation,                 // FDCAN_RX_FIFO0
    //     FDCAN_RxHeaderTypeDef *pRxHeader,    // Filled in by HAL: ID, IdType, length... (&header)
    //     uint8_t *pRxData                     // Filled in by HAL: the data bytes (data)
    // );
    */

    /* TODO 3: If that returned HAL_OK, store the message and raise the flag:
            can_rx_id  = header.Identifier;
            can_rx_ext = (header.IdType == FDCAN_EXTENDED_ID) ? 1 : 0;
            copy the 8 bytes of data into can_rx_data[]
            can_rx_flag = 1;           <- last, so main never sees a half-written message
       Remember: no printing here. Main does that. */

    (void)RxFifo0ITs;
    (void)header;
    (void)data;
}

uint8_t CAN_Training_GetReceived(uint32_t *id, uint8_t *is_extended, uint8_t data[8])
{
    if ((id == NULL) || (is_extended == NULL) || (data == NULL)) return 0;

    /* TODO: Called from the main loop. If can_rx_flag is 0 return 0 (nothing new).
        Otherwise copy the stored id, extended flag and 8 data bytes to the pointers,
        clear can_rx_flag, and return 1. */

    (void)can_rx_flag;
    (void)can_rx_id;
    (void)can_rx_ext;
    (void)can_rx_data;

    return 0;   /* TODO: replace */
}

/* -------------------------------------------------------------------------- */
/*  Part 4: Reporting over the UART                                           */
/* -------------------------------------------------------------------------- */

HAL_StatusTypeDef CAN_Training_PrintReceived(uint32_t id, uint8_t is_extended, const uint8_t data[8])
{
    char message[96];

    /* TODO 1: Build one line with snprintf() that looks like this:
            CAN RX id=0x18FF1234 ext data=00 11 22 33 44 55 66 77
        ending with "\r\n". Use "ext" or "std" depending on is_extended.
        Hints: %08lX with (unsigned long)id prints the ID as hex; %02X prints a byte as two
        hex digits (cast to unsigned). Print the header part first, then loop over the 8
        bytes appending each one: keep a position index and use
        snprintf(&message[pos], sizeof(message) - pos, ...). Never write past the buffer. */

    /* TODO 2: Send it with UART_Training_Print() and return its status. */

    (void)message;
    (void)id;
    (void)is_extended;
    (void)data;

    return HAL_ERROR;   /* TODO: replace */
}

/* TASKS:
 * 1. Complete Parts 1 to 4. Send extended ID 0x18FF1234 with 8 bytes: do you see
 *    "CAN RX id=0x18FF1234 ext ..." in the terminal once per second?
 * 2. The test also sends a STANDARD ID (0x123). It does NOT appear in the terminal. Why?
 *    (Look at the filter and the global filter in Start. How would you change them to
 *    accept it?)
 * 3. Try an extended ID bigger than 0x1FFFFFFF, or a standard ID bigger than 0x7FF.
 *    What goes wrong? How many bits does each type have?
 * 4. Change the number of data bytes sent (FDCAN_DLC_BYTES_4, ...). What happens to the
 *    bytes you did not send?
 * 5. Two nodes send at the same moment: IDs 0x18FF0001 and 0x18FF0002. Which wins and why?
 * 6. Change the filter so only the ID 0x18FF1234 is accepted (ID = 0x18FF1234,
 *    mask = 0x1FFFFFFF). Send 0x18FF1235. Is it received?
 * 7. Why must the callback not call UART_Training_Print()? Estimate how long printing a
 *    60-character line takes at 115200 baud (10 bits per byte). What would happen to other
 *    interrupts and to messages arriving in the meantime?
 * 8. What happens if two messages arrive before the main loop prints the first? How could you
 *    avoid losing one? (A small ring buffer, like the one real CAN code uses.)
 * 9. Optional: HAL also has a TX-complete callback (HAL_FDCAN_TxBufferCompleteCallback).
 *    Read about it in the HAL FDCAN documentation.
 */
